# Keil uVision project HC32L130_Refactored.uvprojx, settings and files
target HC32L130_Refactored (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: HC32L130F8UA HDSC
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0xEE00) CPUTYPE("Cortex-M0+") CLOCK(22120000) ELITTLE
  output: HC32L130_Refactored +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\core;..\app;..\components;..\services;..\platform;..\config;..\vendor\common;..\vendor\driver\inc;..\vendor\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\HC32L130_Refactored.sct
  link misc: --keep=*Handler
  group core
    ../core/: utc_calendar.c
  group app
    ../app/: main.c application.c
  group components
    ../components/: network_manager.c location_manager.c sampling_service.c upload_schedule.c
  group services
    ../services/: at_client.c http_service.c protocol_codec.c report_service.c record_cache.c identity_store.c
  group platform
    ../platform/: board.c interrupt_dispatch.c startup_hc32l130.s
  group vendor
    ../vendor/common/: system_hc32l13x.c
    ../vendor/driver/src/: adc.c bgr.c bt.c ddl.c flash.c gpio.c i2c.c lpm.c rtc.c sysctrl.c uart.c
