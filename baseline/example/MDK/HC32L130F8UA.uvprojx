# Keil uVision project HC32L130F8UA.uvprojx, settings and files
target HC32L130F8UA_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L130F8UA HDSC
  pack: HDSC.HC32L13x.1.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GNSS_V1_4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\source;.\include;..\..\driver\inc;..\..\common;..\..\common;.\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ../../common/: interrupts_hc32l13x.c system_hc32l13x.c startup_hc32l13x.s
  group source
    ../source/: main.c
  group Hardware
    ./src/: hardware.c serial.c network_strategy.c
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group driver
    ../../driver/src/: adc.c bt.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c lcd.c lpm.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c bgr.c
software components: CMSIS:CORE 5.3.0
